Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView]
File name: C:\Users\DennisHoogenboezem\HSR Groep BV\Unitura - Documenten (2)\R&D\Producttekeningen\7. GROENGEVELS (green facades)\Climbers brontekeningen\Complete artikelen\climbers KLMAO4.IFC
Time: 2026-05-28T14:37:55+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC2X3

# IfcProject, Project
Description: Default Project
